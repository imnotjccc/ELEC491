Commit message: 3.26 update

File: tacto/Obsticle_box/urdf/Obsticle_box.urdf (robot description, URDF)
Before this commit: robot Obsticle_box, 1 links, 0 joints
Links:
- link base_link: mass 3.2 -> 1.06666666666667
